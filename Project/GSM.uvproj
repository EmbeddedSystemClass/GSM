# Keil uVision project GSM.uvproj, settings and files
target GSM (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GSM
  c flags: Optim=1 wLevel=2
  c define: STM32L1XX_MD,USE_STDPERIPH_DRIVER
  c include: ..\AppLunch;..\COM;..\Daos;..\Datas;..\Driver;..\Entity;..\Function;..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Task;..\UI;..\ThirdParty\FreeRTOS\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group AppLunch
    ../AppLunch/: main.c stm32l1xx_it.c SystemInit.c
  group Driver
    ../Driver/: BettryADC.c Iwdg_Driver.c Led_Driver.c SimPwrKey_Driver.c Usart2_Driver.c Usart3_Driver.c WakeUpKey.c
  group Function
    ../Function/: HttpClient_Fun.c SIM800_Fun.c UserMain_Fun.c
  group Task
    ../Task/: HttpClient_Task.c Iwdg_Task.c SystemStart_Task.c Universal_Task.c
  group Entity
    ../Entity/: Define.h
  group Datas
    ../Datas/: System_Data.c
  group COM
    ../COM/: CRC_CCITT.c CRC16.c Delay.c Md5.c MyMem.c MyQueue.c MyTools.c QueueUnits.c Utf8ToGBK.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
  group Libraries
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group FreeRTOS
    ../ThirdParty/FreeRTOS/src/: heap_4.c list.c port.c queue.c tasks.c
