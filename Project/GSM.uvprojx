# Keil uVision project GSM.uvprojx, settings and files
target GSM (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GSM +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MD,USE_STDPERIPH_DRIVER
  c include: ..\AppLunch;..\COM;..\Daos;..\Datas;..\Driver;..\Entity;..\Function;..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\Task;..\UI;..\ThirdParty\FreeRTOS\inc;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group AppLunch
    ../AppLunch/: main.c stm32l1xx_it.c SystemInit.c
  group Driver
    ../Driver/: BettryADC.c Led_Driver.c Usart1_Driver.c Pwr_Driver.c
  group Function
    ../Function/: HttpClient_Fun.c SIM800_Fun.c
  group Task
    ../Task/: SystemStart_Task.c
  group Entity
    ../Entity/: Define.h
  group Datas
    ../Datas/: System_Data.c
  group COM
    ../COM/: Delay.c MyQueue.c
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_md.s
  group Libraries
    ../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_gpio.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c stm32l1xx_wwdg.c stm32l1xx_dma.c
